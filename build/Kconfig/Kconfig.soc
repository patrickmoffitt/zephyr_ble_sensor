## build/Kconfig/Kconfig.soc.arch
```kconfig
osource "/home/patrick/zephyrproject/zephyr/soc/$(ARCH)/Kconfig"
osource "/home/patrick/zephyrproject/zephyr/soc/$(ARCH)/*/Kconfig"
```
